# Keil uVision project WireHarnessTester.uvprojx, settings and files
target WireHarnessTester (ARM-ADS)
  device: STM32F429II STMicroelectronics
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: WireHarnessTesterCC_V +hex
  AfterMake: fromelf.exe --bin -o .\HexBin\WT8B26.bin .\Output\WireHarnessTesterCC_V.axf
  AfterMake: .\CopyHex.bat
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,USE_USB_HS,
  c misc: --C99
  c include: ..\..\Application\BSP;..\..\Application\BSP\Common;..\..\Application\Config;..\..\Application\Core\Inc;..\..\Application\Fonts;..\..\Application\Src;..\..\Application\User;..\..\Application\Utilities\CPU;..\..\Application\Utilities\Fonts;..\..\Application\Utilities\MALLOC;..\..\Application\Utilities\Tool;..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\Middlewares\ST\STM32_USB_Host_Library\Core\Inc;..\..\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc;..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\..\Middlewares\ST\STM32_USB_Device_Library\Class\MSC\Inc;..\..\Middlewares\ST\STemWin\inc;..\..\Middlewares\Third_Party\FatFs\src;..\..\Middlewares\Third_Party\FatFs\src\drivers;..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\Middlewares\Third_Party\FreeRTOS\Source\include;..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS;..\..\Middlewares\Third_Party\LwIP\src\include\;..\..\Middlewares\Third_Party\LwIP\src\include\ipv4;..\..\Middlewares\Third_Party\LwIP\system
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x1f0000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Application/BSP
    ../../Application/BSP/: wt_bsp.c wt_bsp.h wt_bsp_ad.c wt_bsp_ad.h wt_bsp_common.h wt_bsp_define.h wt_bsp_eeprom.c wt_bsp_eeprom.h wt_bsp_file.c wt_bsp_file.h wt_bsp_ili6480.c wt_bsp_ili6480.h wt_bsp_infrared.c wt_bsp_infrared.h wt_bsp_io.c wt_bsp_io.h wt_bsp_key_led.c wt_bsp_key_led.h wt_bsp_lcd.c wt_bsp_lcd.h wt_bsp_print.c wt_bsp_print.h wt_bsp_sd.c wt_bsp_sd.h wt_bsp_sdram.c wt_bsp_sdram.h wt_bsp_spi_flash.c wt_bsp_spi_flash.h wt_bsp_storage.c wt_bsp_storage.h wt_bsp_usart.c wt_bsp_usart.h
  group Application/Core
    ../../Application/Core/Src/: k_bsp.c k_module.c k_rtc.c k_storage.c stm32f4xx_it.c
  group Application/Fonts
    ../../Application/Fonts/: GUI_Font12.c GUI_Font16.c GUI_Font24.c GUI_Font32.c GUI_Font48.c GUI_UC_EncodeNone.c GUICharPEx.c HZ_Song_48.c wt_fonts.h
  group Application/Src
    ../../Application/Src/: bm_BackGround480x272A.c bm_board_160x40.c bm_board_null_160x40.c bm_ICO_book.c bm_ICO_debug.c bm_ICO_edit.c bm_ICO_find.c bm_ICO_Info.c bm_ICO_print.c bm_ICO_setting.c bm_ICO_smail.c bm_ICO_study.c bm_ICO_test.c bm_ICO_wheel.c bm_Logo_LZY40x20.c bm_logo_lzy115x84.c bm_StartupA.c bm_test_fail.c bm_test_ok.c bm_test_run.c bm_warn_120x100.c wt_bm_edit.c wt_bm_selftest.c wt_bm_Sourse.c wt_closewarning.c wt_edit_dialog.c wt_edit_save_dialog.c wt_passwd_dialog.c wt_study_dialog .c wt_study_save_dialog.c wt_test_dialog.c wt_testok_box.c wt_warningbox.c
  group Application/User
    ../../Application/User/: main.c main.h verision.h wt_ad_app.c wt_ad_app.h wt_startup.c wt_task_gui.c wt_task_gui.h wt_task_wirefindpoint.c wt_task_wirefindpoint.h wt_task_wireselfcheck.c wt_task_wireselfcheck.h wt_task_wirestudy.c wt_task_wirestudy.h wt_task_wiretest.c wt_task_wiretest.h wt_uart_24GHz.c wt_uart_24GHz.h wt_uart_audio.c wt_uart_audio.h wt_uart_COM1.c wt_uart_COM1.h wt_uart_COM2.c wt_uart_COM2.h wt_windows_config.c wt_windows_edit.c wt_windows_find.c wt_windows_menu.c wt_windows_menu.h wt_windows_print.c wt_windows_selftest.c wt_windows_study.c wt_windows_system.c wt_windows_test.c wt_windows_test.h
  group Application/Utilities
    ../../Application/Utilities/CPU/: cpu_utils.c
    ../../Application/Utilities/MALLOC/: malloc.c
    ../../Application/Utilities/Tool/: task_utils.c tools.c
  group Doc
    ../../Doc/: readme_fast.txt
  group Drivers/CMSIS
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_msp_template.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_usb.c
  group Middlewares/FatFs/Core
    ../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/FatFs/Drivers
    ../../Middlewares/Third_Party/FatFs/src/drivers/: usbh_diskio.c sd_diskio.c
  group Middlewares/FatFs/Options
    ../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Middlewares/FreeRTOS
    ../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c list.c queue.c tasks.c timers.c
  group Middlewares/FreeRTOS/Portable
    ../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/STemWin/Config
    ../../Application/Config/: GUIConf.c LCDConf_WHT.c
  group Middlewares/STemWin/Library
    ../../Middlewares/ST/STemWin/Lib/: STemWin526_CM4_OS_Keil.lib
  group Middlewares/STemWin/OS
    ../../Middlewares/ST/STemWin/OS/: GUI_X_OS.c
  group Middlewares/STM32_USBH_Library/Class/MSC
    ../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group Middlewares/STM32_USBH_Library/Config
    ../../Application/Config/: usbh_conf.c
  group Middlewares/STM32_USBH_Library/Core
    ../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
software components: CMSIS:CORE 5.0.0
